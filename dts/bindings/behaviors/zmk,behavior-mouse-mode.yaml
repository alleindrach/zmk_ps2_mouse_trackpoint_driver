## dts/bindings/behaviors/zmk,behavior-mouse-mode.yaml
```yaml
description: Mouse Mode

compatible: "zmk,behavior-mouse-mode"

include: zero_param.yaml
```
